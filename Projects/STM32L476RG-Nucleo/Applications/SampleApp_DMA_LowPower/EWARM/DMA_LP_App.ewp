# IAR project DMA_LP_App.ewp, settings and files
configuration DMA_LP_App_SERVER (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; SERVER_ROLE; __DMA_LP__
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\Utils; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\Middlewares\ST\TimerServer\inc; ..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc; ..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\STM32L4xx_HAL_BlueNRG_Drivers\inc; ..\STM32xx_HAL_APP_Drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SampleApp_DMA_LP_SERVER_L476RG.bin
  ILINK.IlinkOutputFile: DMA_LP_App.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DMA_LP_App_CLIENT (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; CLIENT_ROLE; __DMA_LP__
  OBJCOPY.OOCOutputFile: SampleApp_DMA_LP_CLIENT_L476RG.bin
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/HAL_APP_Drivers
    ../STM32xx_HAL_APP_Drivers/src/: stm32xx_hal_app_rtc.c
  group Application/User
    ../Src/: app_service.c cube_hal_l4.c gp_timer.c hci_tl.c hci_tl_interface.c low_power_conf_l4.c main.c stm32l4xx_hal_msp.c stm32l4xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble_dma_lp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c
  group Middlewares/BlueNRG-MS/HAL_Drivers
    ../../../../../Middlewares/ST/BlueNRG-MS/STM32L4xx_HAL_BlueNRG_Drivers/src/: stm32l4xx_hal_bluenrg_gpio.c stm32l4xx_hal_bluenrg_syscfg.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/LPM
    ../../../../../Middlewares/ST/LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/TimerServer
    ../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
