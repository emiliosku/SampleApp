# IAR project ProfilesCentral.ewp, settings and files
configuration L476RG (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; SET_L2CAP_CONN_UPD_REQ_COMMAND; SET_TX_POWER_COMMAND
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\profiles\Central\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\Middlewares\ST\TimerServer\inc; ..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PrCentr_PROFNAME_L476RG.bin
  ILINK.IlinkOutputFile: Profiles_Central.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: anc_central_application.c ans_central_application.c bp_central_application.c cube_hal_l4.c fml_central_application.c fmt_central_application.c gc_central_application.c gp_timer.c hci_tl.c hci_tl_interface.c hid_central_application.c hr_central_application.c ht_central_application.c main.c pas_central_application.c pm_central_application.c pr_central_application.c stm32l4xx_hal_msp.c stm32l4xx_it.c tc_central_application.c ts_central_application.c uart_support.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_uart.c
  group Middlewares/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Utils/: timer.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/ANC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/alert_notification_client/: alert_notification_client.c alert_notification_client_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/ANS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/alert_notification_server/: alert_notification_server.c alert_notification_server_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/BLE_Profile
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/ble_profile/: master_basic_profile.c master_basic_profile_sm.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/BPC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/blood_pressure_collector/: blood_pressure_collector.c blood_pressure_collector_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/FML
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/find_me_locator/: find_me_locator.c find_me_locator_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/FMT
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/find_me_target/: find_me_target.c find_me_target_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/GC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/glucose_collector/: glucose_collector.c glucose_collector_CB.c glucose_collector_racp_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/HID
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/hid_host/: hid_host.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/HRC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/heart_rate_collector/: heart_rate_collector.c heart_rate_collector_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/HTC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/health_thermometer_collector/: health_thermometer_collector.c health_thermometer_collector_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/PAS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/phone_alert_status_server/: phone_alert_status_server.c phone_alert_status_server_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/PM
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/proximity_monitor/: proximity_monitor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/PR
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/proximity_reporter/: proximity_reporter.c proximity_reporter_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/TC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/time_client/: time_client.c time_client_CB.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Central/TS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Central/Src/time_server/: time_server.c time_server_CB.c
  group Middlewares/TimerServer
    ../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
