# IAR project Profiles.ewp, settings and files
configuration STM32L476RG_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER; __DMA_LP__
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\profiles\Peripheral\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\Utils; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\Middlewares\ST\TimerServer\inc; ..\..\..\..\..\Middlewares\ST\TimerServer\STM32xx_HAL_TimerServer_Drivers\inc; ..\..\..\..\..\Middlewares\ST\LowPowerManager\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\STM32L4xx_HAL_BlueNRG_Drivers\inc; ..\STM32xx_HAL_APP_Drivers\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ProfPerip_PROFNAME_DMALP_L476RG.bin
  ILINK.IlinkOutputFile: DMA_LP_Profiles.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/HAL_APP_Drivers
    ../STM32xx_HAL_APP_Drivers/src/: stm32xx_hal_app_rtc.c
  group Application/User
    ../Src/: anc_profile_application.c ans_profile_application.c bps_profile_application.c cube_hal_l4.c fml_profile_application.c fmt_profile_application.c gp_timer.c gs_profile_application.c hci_tl.c hci_tl_interface.c hid_profile_application.c hrm_profile_application.c htm_profile_application.c low_power_conf_l4.c main.c pac_profile_application.c pm_profile_application.c pr_profile_application.c profile_application.c stm32l4xx_hal_msp.c stm32l4xx_it.c tc_profile_application.c ts_profile_application.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L476RG_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble_dma_lp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c
  group Middlewares/BlueNRG-MS/HAL_Drivers
    ../../../../../Middlewares/ST/BlueNRG-MS/STM32L4xx_HAL_BlueNRG_Drivers/src/: stm32l4xx_hal_bluenrg_gpio.c stm32l4xx_hal_bluenrg_syscfg.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/ANC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/alert_notification_client/: alertNotification_Client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/ANS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/alert_notification_server/: alertNotification_Server.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/BLE_Profile
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/ble_profile/: profile.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/BPS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/blood_pressure_sensor/: blood_pressure_sensor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/FML
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Find_Me_Locator/: findme_locator.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/FMT
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Find_Me_Target/: findme_target.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/GS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/glucose_sensor/: glucose_racp.c glucose_sensor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HID
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/hid_device/: hid_device.c hid_device_sm_services.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HR
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/heart_rate/: heart_rate.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/HT
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Health_Thermometer/: health_thermometer.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PAC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/Phone_Alert_Client/: phoneAlert_Client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PM
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/proximity_monitor/: proximity_monitor.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/PR
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/proximity_reporter/: proximity_reporter.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/TC
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/time_client/: time_client.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/Peripheral/TS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Src/time_server/: time_server.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/Peripheral/Utils/: timer.c
  group Middlewares/LPM
    ../../../../../Middlewares/ST/LowPowerManager/Src/: stm32xx_lpm.c
  group Middlewares/TimerServer
    ../../../../../Middlewares/ST/TimerServer/src/: stm32xx_timerserver.c
