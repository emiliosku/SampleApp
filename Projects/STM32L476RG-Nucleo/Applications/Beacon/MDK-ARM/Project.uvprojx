# Keil uVision project Project.uvprojx, settings and files
target Beacon (ARM-ADS)
  device: STM32L476RGTx STMicroelectronics
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Beacon
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/BlueNRG-MS/includes/;../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/;../../../../../Middlewares/ST/BlueNRG-MS/utils/
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: app_bluenrg-ms.c stm32l4xx_hal_msp.c hci_tl_interface.c stm32l4_nucleo_l476rg.c stm32l4xx_it.c stm32l4xx_hal_exti.c main.c eddystone_beacon.c hci.c sensor_service.c nucleo_l476rg_bus.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_rcc.c
  group Middlewares/X-CUBE-BLE1/Wireless/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/X-CUBE-BLE1/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/X-CUBE-BLE1/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_hal_aci.c bluenrg_gatt_aci.c bluenrg_gap_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_IFR.c bluenrg_utils_small.c
software components: CMSIS:CORE 4.3.0
