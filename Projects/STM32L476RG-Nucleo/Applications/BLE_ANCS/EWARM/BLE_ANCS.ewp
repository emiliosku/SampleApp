# IAR project BLE_ANCS.ewp, settings and files
configuration BLE_ANCS_L4xx_NUCLEO (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_STM32L4XX_NUCLEO; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32L4xx_Nucleo; ..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDB0xA1; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\profiles\ANCS\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_ANCS_L476RG.bin
  ILINK.IlinkOutputFile: BLE_ANCS.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: BLE_ANCS_main.c cube_hal_l4.c demo_application.c gp_timer.c hci_tl.c hci_tl_interface.c stm32l4xx_hal_msp.c stm32l4xx_it.c uart_support.c user_timer.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_NUCLEO
    ../../../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Drivers/BSP/X-NUCLEO-IDB0xA1
    ../../../../../Drivers/BSP/X-NUCLEO-IDB0xA1/: stm32_bluenrg_ble.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Template
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Profiles/ANCS
    ../../../../../Middlewares/ST/BlueNRG-MS/profiles/ANCS/Src/: ancs.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
