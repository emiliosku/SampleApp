# Keil uVision project Project.uvprojx, settings and files
target Beacon (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x20017FFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Beacon
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/BlueNRG-MS/includes/;../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/;../../../../../Middlewares/ST/BlueNRG-MS/utils/
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: app_bluenrg-ms.c hci_tl_interface.c stm32f4xx_hal_msp.c main.c eddystone_beacon.c hci.c nucleo_f401re_bus.c stm32f4xx_it.c sensor_service.c stm32f4xx_hal_exti.c stm32f4_nucleo_f401re.c
  group Middlewares/X-CUBE-BLE1/Wireless/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c
  group Middlewares/X-CUBE-BLE1/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/X-CUBE-BLE1/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_hal_aci.c bluenrg_gatt_aci.c bluenrg_gap_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_IFR.c bluenrg_utils_small.c
software components: CMSIS:CORE 4.3.0
