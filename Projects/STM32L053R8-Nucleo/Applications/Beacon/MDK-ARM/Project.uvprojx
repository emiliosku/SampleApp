# Keil uVision project Project.uvprojx, settings and files
target Beacon (ARM-ADS)
  device: STM32L053R8Tx STMicroelectronics
  cpu: IROM(0x08000000-0x800FFFF) IRAM(0x20000000-0x20001FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Beacon
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Middlewares/ST/BlueNRG-MS/includes/;../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/;../../../../../Middlewares/ST/BlueNRG-MS/utils/
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/User
    ../Src/: nucleo_l053r8_bus.c app_bluenrg-ms.c stm32l0xx_hal_msp.c hci_tl_interface.c main.c eddystone_beacon.c hci.c stm32l0xx_it.c stm32l0_nucleo_l053r8.c stm32l0xx_hal_exti.c sensor_service.c
  group Middlewares/X-CUBE-BLE1/Wireless/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/X-CUBE-BLE1/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_spi.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_dma.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal.c stm32l0xx_hal_flash_ex.c
  group Middlewares/X-CUBE-BLE1/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_hal_aci.c bluenrg_gatt_aci.c bluenrg_gap_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_IFR.c bluenrg_utils_small.c
software components: CMSIS:CORE 4.3.0
